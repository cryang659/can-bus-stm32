# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Firmware\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Firmware\STM32F10x_StdPeriph_Driver\inc;..\Firmware\CMSIS\CM3\CoreSupport;..\User
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../Firmware/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
    ../Firmware/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../Firmware/CMSIS/CM3/CoreSupport/: core_cm3.c
  group Firmware
    ../Firmware/STM32F10x_StdPeriph_Driver/src/: stm32f10x_can.c stm32f10x_gpio.c stm32f10x_rtc.c stm32f10x_rcc.c stm32f10x_i2c.c
  group User
    ../User/: main.c
